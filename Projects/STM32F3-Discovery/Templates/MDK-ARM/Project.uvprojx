# Keil uVision project Project.uvprojx, settings and files
target STM32F3-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x803FFFF) IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32F3_DISCO
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../../../Drivers/STM32F3xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F3-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F3-Discovery
    ../../../../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
  group Example/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
target STM32F3-Discovery_ASSERT_V6 (6070000::V6.7::.\ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: as above
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32F3_DISCO
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 5.3.0
