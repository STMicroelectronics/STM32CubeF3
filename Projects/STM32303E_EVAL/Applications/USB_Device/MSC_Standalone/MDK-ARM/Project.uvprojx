# Keil uVision project Project.uvprojx, settings and files
target STM32F303xE_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303xE_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F303xE,USE_HAL_DRIVER,USE_STM32303E_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32303E_EVAL;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval.c stm32303e_eval_sd.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc.c usbd_msc_data.c usbd_msc_bot.c
  group Application/User
    ../Src/: usbd_storage.c main.c stm32f3xx_it.c usbd_desc.c usbd_conf.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal.c stm32f3xx_hal_pcd.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.1.0
